# IAR project SimpleBLEPeripheral.ewp, settings and files
configuration CC2541DK-MINI Keyfob (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\Includes\common; ..\..\Includes\hal\include; ..\..\Includes\hal\target\CC2540EB; ..\..\Includes\osal\include; ..\..\Includes\services\saddr; ..\..\Includes\ble\include; ..\..\Includes\ble\controller\phy; ..\..\Includes\ble\controller\include; ..\..\Includes\ble\hci; ..\..\Includes\ble\host; ..\..\Includes\common\cc2540; ..\..\Includes\servapps; ..\..\Includes\profile\Roles; ..\..\Includes\profile\SimpleProfile; ..\Source; $PROJ_DIR$
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: ..\..\Includes\common; ..\..\Includes\servapps; ..\..\Includes\hal\include; ..\..\Includes\hal\target\CC2540EB; ..\..\Includes\osal\include; ..\..\Includes\osal\common; ..\..\Includes\services\saddr; ..\..\Includes\ble\include; ..\..\Includes\ble\controller\phy; ..\..\Includes\ble\controller\include; ..\..\Includes\ble\hci; ..\..\Includes\ble\host; ..\..\Includes\common\cc2540; ..\..\Includes\profile\Roles; ..\..\Includes\profile\SimpleProfile; ..\..\Includes\profile\DevInfo; $PROJ_DIR$
  ICC8051.CCOptLevel: 2
  XLINK.XclFile: C:\Users\Andrew\IMU\SimpleBLE\Includes\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: i2c.c i2c.h MPU9150.c MPU9150.h OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c simpleBLEPeripheral.h SimpleBLEPeripheral_Main.c
    ./: led.c led.h radio.c radio.h
  group HAL/Common
    ../../Includes/hal/common/: hal_drivers.c
  group HAL/Include
    ../../Includes/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../Includes/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../Includes/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../Includes/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../Includes/hal/target/CC2540EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../Includes/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../Includes/ble/hci/: hci_c_data.h hci_c_event.h hci_controller.h
    ../../Includes/ble/host/: linkdb.h
    ../../Includes/ble/controller/include/: ll.h ll_sleep.h phy.h phy_image.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_ble_single_chip_peri.lib
  group OSAL
    ../../Includes/ble/include/: bcomdef.h
    ../../Includes/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../Includes/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Includes/profile/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Includes/profile/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Includes/servapps/: gapgattserver.h gattservapp.h
    ../../Includes/ble/host/: gatt_uuid.c
    ../../Profiles/Roles/: peripheralBroadcaster.c peripheralBroadcaster.h
    ../../Includes/profile/SimpleProfile/: simpleGATTprofile.c simpleGATTprofile.h
    ../../Profiles/Keys/: simplekeys.c simplekeys.h
  group TOOLS
    ../../../config/: buildComponents.cfg buildConfig.cfg
    ../../Includes/common/cc2540/: OnBoard.c OnBoard.h
